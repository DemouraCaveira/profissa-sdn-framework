options:
  parameters:
    author: jon
    generate_options: qt_gui
    id: ping_entre_hosts
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("tick")
    period: '1'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "import time\nimport subprocess\nfrom gnuradio import gr\nimport pmt\n\nclass ForwardingTableS1(gr.basic_block):\n    def __init__(self, container_name=\"s1\", update_interval=5.0, colorize=False):\n        gr.basic_block.__init__(\n            self,\n            name=\"ForwardingTableS1\",\n            in_sig=[],\n            out_sig=[]\n        )\n\n        self.container_s1 = container_name\n        self.update_interval = update_interval\n        self.colorize = colorize\n        self.last_update = 0\n        self.last_stats = {}  # {priority: (packets, bytes)}\n\n        # Portas de mensagens\n        self.message_port_register_in(pmt.intern(\"tick\"))\n        self.message_port_register_out(pmt.intern(\"out\"))\n        self.set_msg_handler(pmt.intern(\"tick\"), self._on_tick)\n\n    # ---------- Descoberta/execução ----------\n    def _detect_bridge_name(self):\n        try:\n            result = subprocess.run(\n                [\"docker\", \"exec\", self.container_s1, \"ovs-vsctl\", \"list-br\"],\n                capture_output=True, text=True, timeout=5\n            )\n            bridges = [b.strip() for b in result.stdout.splitlines() if b.strip()]\n            return bridges[0] if bridges else None\n        except Exception:\n            return None\n\n    def _run(self, *cmd, timeout=5):\n        try:\n            result = subprocess.run(cmd, capture_output=True, text=True, timeout=timeout)\n            return (result.stdout + result.stderr).strip()\n        except subprocess.TimeoutExpired:\n            return \"Timeout ao executar: \" + \" \".join(cmd)\n        except Exception as e:\n            return f\"Erro ao executar {' '.join(cmd)}: {e}\"\n\n    def _get_forwarding_table_raw(self):\n        bridge_name = self._detect_bridge_name()\n        if not bridge_name:\n            return None, \"Nenhum bridge encontrado no container.\"\n        output = self._run(\"docker\", \"exec\", self.container_s1,\n                           \"ovs-ofctl\", \"dump-flows\", bridge_name)\n        return bridge_name, output\n\n    # ---------- Parsing ----------\n    def _extract_field(self, line, key):\n        for part in line.split():\n            if part.startswith(key + \"=\"):\n                val = part.split(\"=\", 1)[1]\n                return val.rstrip(\",\")\n        return None\n\n    def _parse_flows(self, raw):\n        lines = raw.splitlines()\n        flows = []\n        for line in lines:\n            if \"priority=\" in line and \"actions=\" in line:\n                clean = line.replace(\",\", \" \")\n                prio = self._extract_field(clean, \"priority\")\n                pkts = self._extract_field(clean, \"n_packets\")\n                byts = self._extract_field(clean, \"n_bytes\")\n                acts = self._extract_field(clean, \"actions\")\n                if prio is None or pkts is None or byts is None or acts is None:\n                    continue\n                try:\n                    pkts_i = int(pkts)\n                    byts_i = int(byts)\n                except Exception:\n                    continue\n                flows.append((prio, pkts_i, byts_i, acts))\n        return flows\n\n    # ---------- Formatação ----------\n    def _format_output(self, bridge, flows):\n        ts = time.strftime(\"%Y-%m-%d %H:%M:%S\")\n        header = f\"[{ts}] bridge={bridge}\\n\"\n        header += f\"{'Prio':>4} {'Pkts':>6} {'ΔPkt':>5} {'Bytes':>8} {'ΔB':>6} Actions\\n\"\n        header += \"-\" * 50 + \"\\n\"\n\n        if not flows:\n            return header + \"Nenhum fluxo encontrado.\\n\"\n\n        rows = []\n        for prio, pkts, byts, acts in flows:\n            last_p, last_b = self.last_stats.get(prio, (pkts, byts))\n            d_p = pkts - last_p\n            d_b = byts - last_b\n            self.last_stats[prio] = (pkts, byts)\n            rows.append(f\"{prio:>4} {pkts:>6} {d_p:+5} {byts:>8} {d_b:+6} {acts}\")\n\n        return header + \"\\n\".join(rows) + \"\\n\"\n\n    # ---------- Tick ----------\n    def _on_tick(self, msg):\n        if time.time() - self.last_update < self.update_interval:\n            return\n\n        bridge, raw = self._get_forwarding_table_raw()\n        if bridge is None:\n            final_output = f\"[{time.strftime('%Y-%m-%d %H:%M:%S')}] {raw}\\n\"\n        else:\n            flows = self._parse_flows(raw)\n            final_output = self._format_output(bridge, flows)\n\n        # Terminal\n        print(final_output, end=\"\")\n\n        # Envia para GUI\n        self.message_port_pub(pmt.intern(\"out\"), pmt.to_pmt(final_output))\n\n        self.last_update = time.time()\n\n"
    colorize: 'True'
    container_name: '''s1'''
    update_interval: '0.5'
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    is_pair: 'False'
    is_static: 'False'
    type: string
  states: {}

connections:
- [blocks_message_strobe_0, strobe, epy_block_0, tick]
- [epy_block_0, out, qtgui_edit_box_msg_0, val]

metadata:
  file_format: 1
