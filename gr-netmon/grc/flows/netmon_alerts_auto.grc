options:
  parameters:
    author: netmon
    category: '[Network]/Monitoring'
    description: Alerts from host ping raw files
    generate_options: qt_gui
    id: netmon_alerts_auto
    output_language: python
    title: Alerts (auto)
  states: {}

blocks:
- name: netmon_alerts_0
  id: netmon_alerts
  parameters:
    files: ./raw/host_ping_auto.txt
    interval: '2.0'
    latency_threshold_ms: '50.0'
    loss_threshold_pct: '10.0'
    jitter_threshold_ms: '20.0'
    log_to_file: 'True'
    log_dir: ./raw
  states: {}
- name: null_src_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: throttle_0
  id: blocks_throttle
  parameters:
    sample_rate: '100'
    type: float
  states: {}
- name: null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}

connections:
- [null_src_0, '0', throttle_0, '0']
- [throttle_0, '0', null_sink_0, '0']

metadata:
  file_format: 1
