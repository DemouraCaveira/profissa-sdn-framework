options:
  parameters:
    author: netmon
    category: '[Network]/Monitoring'
    description: Link interface counters inside Docker container
    generate_options: qt_gui
    id: netmon_link_interface_stats_auto
    output_language: python
    title: Link Interface Stats (auto)
  states: {}

blocks:
- name: netmon_link_interface_stats_0
  id: netmon_link_interface_stats
  parameters:
    container_name: h1
    interval: '2.0'
    log_to_file: 'True'
    log_dir: ./raw
  states: {}
- name: null_src_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: message_debug_0
  id: blocks_message_debug
  parameters:
    type: message
  states: {}
- name: throttle_0
  id: blocks_throttle
  parameters:
    sample_rate: samp_rate
    type: float
  states: {}
- name: null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100'
  states: {}

connections:
- [null_src_0, '0', throttle_0, '0']
- [throttle_0, '0', null_sink_0, '0']
- [netmon_link_interface_stats_0, metrics, message_debug_0, print]

metadata:
  file_format: 1
