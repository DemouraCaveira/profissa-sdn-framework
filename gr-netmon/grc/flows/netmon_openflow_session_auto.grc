options:
  parameters:
    author: netmon
    category: '[Network]/Monitoring'
    description: Monitor OpenFlow session on switch container
    generate_options: qt_gui
    id: netmon_openflow_session_auto
    output_language: python
    title: OpenFlow Session (auto)
  states: {}

blocks:
- name: netmon_openflow_session_0
  id: netmon_openflow_session
  parameters:
    container_name: s1
    interval: '5.0'
    log_to_file: 'True'
    log_dir: ./raw
  states: {}
- name: null_src_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: message_debug_0
  id: blocks_message_debug
  parameters:
    type: message
  states: {}
- name: throttle_0
  id: blocks_throttle
  parameters:
    sample_rate: samp_rate
    type: float
  states: {}
- name: null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100'
  states: {}

connections:
- [null_src_0, '0', throttle_0, '0']
- [throttle_0, '0', null_sink_0, '0']
- [netmon_openflow_session_0, metrics, message_debug_0, print]

metadata:
  file_format: 1
