options:
  parameters:
    author: netmon
    category: '[Network]/Monitoring'
    description: 'Hier block: Forwarding Table S1 (msg) with message strobe and edit box'
    generate_options: qt_gui
    id: netmon_forwarding_table_s1_msg_hier
    output_language: python
    title: Forwarding Table S1 (msg)
  states: {}

blocks:
- name: netmon_forwarding_table_s1_msg_0
  id: netmon_forwarding_table_s1_msg
  parameters:
    container_name: s1
    update_interval: '1.0'
    colorize: 'False'
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("tick")
    period: '1'
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    is_pair: 'False'
    is_static: 'False'
    type: string
  states: {}

connections:
- [blocks_message_strobe_0, strobe, netmon_forwarding_table_s1_msg_0, tick]
- [netmon_forwarding_table_s1_msg_0, out, qtgui_edit_box_msg_0, val]

metadata:
  file_format: 1
