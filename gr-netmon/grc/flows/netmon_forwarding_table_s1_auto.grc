options:
  parameters:
    author: netmon
    category: '[Network]/Monitoring'
    description: 'Hier block: Forwarding Table S1 (auto) with keepalive stream'
    generate_options: qt_gui
    id: netmon_forwarding_table_s1_auto
    output_language: python
    title: Forwarding Table S1 (auto)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("tick")
    period: '1'
  states: {}
- name: message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: netmon_forwarding_table_s1_0
  id: netmon_forwarding_table_s1
  parameters:
    auto_start: 'True'
    bridge_override: ''
    colorize: 'False'
    container_name: s1
    log_dir: ./raw
    log_to_file: 'True'
    update_interval: '1.0'
  states: {}
- name: null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: null_src_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    is_pair: 'False'
    is_static: 'False'
    type: string
  states: {}
- name: throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}

connections:
- [blocks_message_strobe_0, strobe, netmon_forwarding_table_s1_0, tick]
- [netmon_forwarding_table_s1_0, metrics, message_debug_0, print]
- [netmon_forwarding_table_s1_0, out, qtgui_edit_box_msg_0, val]
- [null_src_0, '0', throttle_0, '0']
- [throttle_0, '0', null_sink_0, '0']

metadata:
  file_format: 1
