options:
  parameters:
    author: jon
    description: Consulta periódica da tabela de encaminhamento do switch s1
    generate_options: qt_gui
    id: tabela_encaminhamento_S1
    output_language: python
    title: Tabela de Encaminhamento S1 (AUTO)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '100'
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("tick")
    period: '1'
  states: {}
- name: netmon_forwarding_table_s1_0
  id: netmon_forwarding_table_s1
  parameters:
    container_name: s1
    update_interval: '1.0'
    colorize: 'False'
    log_to_file: 'False'
    log_dir: ./raw
    auto_start: 'True'
    bridge_override: ''
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    is_pair: 'False'
    is_static: 'False'
    type: string
  states: {}
- name: message_debug_0
  id: blocks_message_debug
  parameters:
    type: message
  states: {}
- name: null_src_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: throttle_0
  id: blocks_throttle
  parameters:
    sample_rate: samp_rate
    type: float
  states: {}
- name: null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}

connections:
- [null_src_0, '0', throttle_0, '0']
- [throttle_0, '0', null_sink_0, '0']
- [blocks_message_strobe_0, strobe, netmon_forwarding_table_s1_0, tick]
- [netmon_forwarding_table_s1_0, out, qtgui_edit_box_msg_0, val]
- [netmon_forwarding_table_s1_0, metrics, message_debug_0, print]

metadata:
  file_format: 1
