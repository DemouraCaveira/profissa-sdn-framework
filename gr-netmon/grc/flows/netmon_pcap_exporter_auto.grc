options:
  parameters:
    author: netmon
    category: '[Network]/Monitoring'
    description: Tcpdump PCAP exporter with rotation
    generate_options: qt_gui
    id: netmon_pcap_exporter_auto
    output_language: python
    title: PCAP Exporter (auto)
  states: {}

blocks:
- name: netmon_pcap_exporter_0
  id: netmon_pcap_exporter
  parameters:
    container_name: h1
    interface: eth0
    filter: ip
    pcap_dir: /tmp
    file_prefix: capture
    duration: '10'
    interval: '10.0'
  states: {}
- name: null_src_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: throttle_0
  id: blocks_throttle
  parameters:
    sample_rate: samp_rate
    type: float
  states: {}
- name: null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100'
  states: {}

connections:
- [null_src_0, '0', throttle_0, '0']
- [throttle_0, '0', null_sink_0, '0']

metadata:
  file_format: 1
