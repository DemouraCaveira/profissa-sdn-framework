options:
  parameters:
    author: netmon
    category: '[Network]/Monitoring'
    description: IP header sampling via tcpdump inside container
    generate_options: qt_gui
    id: netmon_ip_header_capture_auto
    output_language: python
    title: IP Header Capture (auto)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '100'
  states: {}
- name: netmon_ip_header_capture_0
  id: netmon_ip_header_capture
  parameters:
    container_name: h1
    count: '1'
    filter: ip
    interface: eth0
    interval: '1.0'
    log_dir: ./raw
    log_to_file: 'True'
  states: {}
- name: null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: null_src_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}

connections:
- [null_src_0, '0', throttle_0, '0']
- [throttle_0, '0', null_sink_0, '0']

metadata:
  file_format: 1
